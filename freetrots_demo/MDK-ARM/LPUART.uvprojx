# Keil uVision project LPUART.uvprojx, settings and files
target LPUART (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32U083RCTx STMicroelectronics
  pack: Keil.STM32U0xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x803FFFF)  CLOCK(25000000) CPUTYPE("Cortex-M0+") TZ
  output: LPUART +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32U083xx
  c include: ../Core/Inc;../Drivers/STM32U0xx_HAL_Driver/Inc;../Drivers/STM32U0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32U0xx/Include;../Drivers/CMSIS/Include;..\middlewares\freertos\include;..\Core;..\middlewares\freertos\port\RVDS\ARM_CM0;..\app;..\middlewares\freertos\include;..\middlewares\letter_shell
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --keep shellCommand*
  group Application/MDK-ARM
    ./: startup_stm32u083xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c usart.c stm32u0xx_it.c stm32u0xx_hal_msp.c
  group Drivers/STM32U0xx_HAL_Driver
    ../Drivers/STM32U0xx_HAL_Driver/Src/: stm32u0xx_hal_cortex.c stm32u0xx_hal_rcc.c stm32u0xx_hal_rcc_ex.c stm32u0xx_hal_flash.c stm32u0xx_hal_flash_ex.c stm32u0xx_hal_gpio.c stm32u0xx_hal_dma.c stm32u0xx_hal_dma_ex.c stm32u0xx_hal_pwr.c stm32u0xx_hal_pwr_ex.c stm32u0xx_hal.c stm32u0xx_hal_exti.c stm32u0xx_hal_uart.c stm32u0xx_hal_uart_ex.c stm32u0xx_hal_tim.c stm32u0xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32u0xx.c
  group freertos/src
    ../middlewares/freertos/src/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/port
    ../middlewares/freertos/port/MemMang/: heap_4.c
    ../middlewares/freertos/port/RVDS/ARM_CM0/: port.c
  group app
    ../app/: shell_extend.c timers_control.c
  group letter_shell
    ../middlewares/letter_shell/: shell.c shell_cmd_list.c shell_companion.c shell_ext.c shell_port.c
software components: CMSIS:CORE 5.5.0
